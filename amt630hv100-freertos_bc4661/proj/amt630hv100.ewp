# IAR project amt630hv100.ewp, settings and files
configuration LVGL (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: AMT630HV100; VG_DRIVER; CARLINK_ENABLE
  ICCARM.CCDiagSuppress: Pa050,Pe188,Pa118,Pe111,Pa089,Ms014,Pe301
  ICCARM.CCIncludePath2: ..\.; ..\FreeRTOS\Source\include; ..\FreeRTOS\Source\portable; ..\demo\common\include; ..\ArkmicroFiles\libboard-amt630hv100; ..\ArkmicroFiles\libboard-amt630hv100\include; ..\ArkmicroFiles\libcpu-amt630hv100; ..\ArkmicroFiles\libcpu-amt630hv100\include; ..\ArkmicroFiles\libcpu-amt630hv100\source\audio; ..\lib\sfud\inc; ..\lib\gdi; ..\lib\LittlevGL; ..\lib\lib_rtos; ..\lib\vg_driver; ..\lib\romfile; ..\lib\ulog; ..\lib\ulog\backend; ..\lib\EasyFlash\inc; ..\lib\HPatch; ..\FreeRTOS-Plus\FreeRTOS-Plus-CLI; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include\portable; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\private; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\FreeRTOS-Plus\FreeRTOS-FAT\include\; ..\FreeRTOS-Plus\FreeRTOS-FAT\portable\common; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\linux\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\asm\; ..\lib\hx170dec\include; ..\lib\wlan\; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\include\; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\NetworkInterface\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\NetworkInterface\rtl8821cs; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\Compiler\IAR\; ..\lib\bt\fsc_bt\; ..\app\carlink\common\; ..\app\carlink\EY\; ..\app\carlink\EC\src\; ..\app\carlink\EC\include\; ..\app\carlink\CP\src\; ..\app\carlink\CP\include\; ..\app\carlink\AA\src\; ..\app\carlink\AA\include\; ..\lib\awtk\awtk\3rd\zlib; ..\lib\lwip\src\include\; ..\lib\lwip\src\include\lwip\; ..\lib\lwip\src\include\arch\; ..\lib\lwip\src\include\compat\; ..\lib\lwip\src\include\netif\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\.; ..\FreeRTOS\Source\portable
  OBJCOPY.OOCOutputFile: amt630hv100.bin
  postbuild: gen_checksum.exe LVGL\Exe\amt630hv100.bin
  ILINK.IlinkOutputFile: amt630hv100.out
  ILINK.IlinkIcfFile: amt630hv100_lvgl.icf
  ILINK.IlinkAdditionalLibs: ..\lib\vg_driver\VG_DRIVER.a; ..\lib\LittlevGL\lvgl.a; ..\lib\wlan\rtl8821cs\wlan_lib\wlan_lib.a; ..\lib\wlan\rtl8821cs\wlan_lib\wlan_lib_if.a; ..\lib\bt\fsc_bt\lib\blueware.a; ..\app\carlink\EC\lib\ECTiny.a; ..\lib\faad2\libfaad.a; ..\lib\opus\opus.a; ..\lib\wolfssl\wolfssl.a; ..\app\carlink\CP\lib\carplay.a; ..\app\carlink\AA\lib\AndroidAuto.a
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration VG_ONLLY (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AMT630HV100; VG_DRIVER; VG_ONLY; CARLINK_ENABLE; DOUBLE_POINTER_HALO
  ICCARM.CCIncludePath2: ..\.; ..\FreeRTOS\Source\include; ..\FreeRTOS\Source\portable; ..\demo\common\include; ..\ArkmicroFiles\libboard-amt630hv100; ..\ArkmicroFiles\libboard-amt630hv100\include; ..\ArkmicroFiles\libcpu-amt630hv100; ..\ArkmicroFiles\libcpu-amt630hv100\include; ..\ArkmicroFiles\libcpu-amt630hv100\source\audio; ..\lib\sfud\inc; ..\lib\gdi; ..\lib\LittlevGL; ..\lib\lib_rtos; ..\lib\vg_driver; ..\lib\romfile; ..\lib\ulog; ..\lib\ulog\backend; ..\lib\EasyFlash\inc; ..\lib\HPatch; ..\FreeRTOS-Plus\FreeRTOS-Plus-CLI; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include\portable; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\private; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\FreeRTOS-Plus\FreeRTOS-FAT\include\; ..\FreeRTOS-Plus\FreeRTOS-FAT\portable\common; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\linux\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\asm\; ..\lib\hx170dec\include; ..\lib\wlan\; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\include\; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\NetworkInterface\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\NetworkInterface\rtl8821cs; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\Compiler\IAR\; ..\lib\bt\fsc_bt\; ..\app\carlink\common\; ..\app\carlink\EY\; ..\app\carlink\EC\src\; ..\app\carlink\EC\include\; ..\app\carlink\CP\src\; ..\app\carlink\CP\include\; ..\app\carlink\AA\src\; ..\app\carlink\AA\include\; ..\lib\awtk\awtk\3rd\zlib; ..\lib\awtk\awtk\3rd\awtk-widget-qr\src; ..\lib\awtk\awtk\3rd\awtk-widget-qr\src\qr; ..\lib\lwip\src\include\; ..\lib\lwip\src\include\lwip\; ..\lib\lwip\src\include\arch\; ..\lib\lwip\src\include\compat\; ..\lib\lwip\src\include\netif\
  postbuild: gen_checksum.exe VG_ONLY\Exe\amt630hv100.bin
  ILINK.IlinkIcfFile: amt630hv100_vgonly.icf
  ILINK.IlinkAdditionalLibs: ..\lib\vg_driver\VG_DRIVER.a; ..\lib\wlan\rtl8821cs\wlan_lib\wlan_lib.a; ..\lib\wlan\rtl8821cs\wlan_lib\wlan_lib_if.a; ..\lib\bt\fsc_bt\lib\blueware.a; ..\app\carlink\EC\lib\ECTiny.a; ..\lib\faad2\libfaad.a; ..\lib\opus\opus.a; ..\lib\wolfssl\wolfssl.a; ..\app\carlink\CP\lib\carplay.a; ..\app\carlink\AA\lib\AndroidAuto.a
configuration AWTK (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AMT630HV100; VG_DRIVER; AWTK; CARLINK_ENABLE; OSD_WIDTH=800; OSD_HEIGHT=480; HMI_AWTK; FREERTOS=1; USE_GUI_MAIN; LCD=VG_GPU; WITH_ASSET_LOADER; WITH_FS_RES; WITH_VGCANVAS; WITH_UNICODE_BREAK; HAS_PTHREAD=1; HAS_GET_TIME_US64; WITH_VG_GPU; WITH_FT_FONT; WITH_NANOVG_VG; XM_HMI_HOST; HAVE_CLOCK_GETTIME; USE_ROMFS_FS; APP_RES_ROOT="./"; __WITH_ARK_G2D
  ICCARM.CCIncludePath2: ..\.; ..\FreeRTOS\Source\include; ..\FreeRTOS\Source\portable; ..\demo\common\include; ..\ArkmicroFiles\libboard-amt630hv100; ..\ArkmicroFiles\libboard-amt630hv100\include; ..\ArkmicroFiles\libcpu-amt630hv100; ..\ArkmicroFiles\libcpu-amt630hv100\source\audio; ..\ArkmicroFiles\libcpu-amt630hv100\include; ..\lib\sfud\inc; ..\lib\gdi; ..\lib\LittlevGL; ..\lib\lib_rtos; ..\lib\littlefs; ..\lib\vg_driver; ..\lib\romfile; ..\lib\ulog; ..\lib\ulog\backend; ..\lib\EasyFlash\inc; ..\lib\HPatch; ..\FreeRTOS-Plus\FreeRTOS-Plus-CLI; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include\portable; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\private; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\FreeRTOS-Plus\FreeRTOS-FAT\include\; ..\FreeRTOS-Plus\FreeRTOS-FAT\portable\common; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\linux\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\asm\; ..\lib\awtk\awtk\3rd\xm\include; ..\lib\awtk\awtk\3rd\xm\include\vg; ..\lib\awtk\awtk\3rd\nanovg\base; ..\lib\awtk\awtk\src; ..\lib\awtk\awtk\src\ext_widgets; ..\lib\awtk\awtk\3rd\zlib; ..\lib\hx170dec\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\include\; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\NetworkInterface\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\NetworkInterface\rtl8821cs; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\Compiler\IAR\; ..\lib\bt\fsc_bt\; ..\app\carlink\common\; ..\app\carlink\EY\; ..\app\carlink\EC\src\; ..\app\carlink\EC\include\; ..\app\carlink\CP\src\; ..\app\carlink\CP\include\; ..\app\carlink\AA\src\; ..\app\carlink\AA\include\; ..\app\carlink\clcast\src\; ..\app\carlink\clcast\include\; ..\lib\awtk\awtk\3rd\awtk-widget-qr\src; ..\lib\awtk\awtk\3rd\awtk-widget-qr\src\qr; ..\lib\lwip\src\include\; ..\lib\lwip\src\include\lwip\; ..\lib\lwip\src\include\arch\; ..\lib\lwip\src\include\compat\; ..\lib\lwip\src\include\netif\; ..\lib\wlan; ..\lib\wlan\atbm_wifi6; ..\app\vb7012_voice_assistant; ..\lib\bt\brt_bt\
  postbuild: gen_checksum.exe AWTK\Exe\amt630hv100.bin
  ILINK.IlinkIcfFile: amt630hv100_awtk.icf
  ILINK.IlinkAdditionalLibs: ..\lib\vg_driver\VG_DRIVER_AWTK.a; ..\lib\awtk\awtk_rgb565.a; ..\lib\awtk\nanovg.a; ..\lib\wlan\atbm_wifi6\wlan_lib\wifi_gt.a; ..\lib\wlan\atbm_wifi6\wlan_lib\wifi_gt_if.a; ..\lib\bt\brt_bt\lib\brlink.a; ..\app\carlink\EC\lib\ECTiny.a; ..\app\carlink\clcast\lib\clcast.a; ..\lib\faad2\libfaad.a; ..\lib\opus\opus.a; ..\lib\wolfssl\wolfssl.a; ..\app\carlink\CP\lib\carplay.a; ..\app\carlink\AA\lib\AndroidAuto.a; ..\lib\bt\brt_bt\lib\brlink_stack.a
configuration AWTK_BW3583 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AMT630HV100; VG_DRIVER; AWTK; CARLINK_ENABLE; OSD_WIDTH=800; OSD_HEIGHT=480; HMI_AWTK; FREERTOS=1; USE_GUI_MAIN; LCD=VG_GPU; WITH_ASSET_LOADER; WITH_FS_RES; WITH_VGCANVAS; WITH_UNICODE_BREAK; HAS_PTHREAD=1; HAS_GET_TIME_US64; WITH_VG_GPU; WITH_FT_FONT; WITH_NANOVG_VG; XM_HMI_HOST; HAVE_CLOCK_GETTIME; USE_ROMFS_FS; APP_RES_ROOT="./"; __WITH_ARK_G2D; CHIPSET_SUPPORT_AIC8800D=1
  ICCARM.CCIncludePath2: ..\.; ..\FreeRTOS\Source\include; ..\FreeRTOS\Source\portable; ..\demo\common\include; ..\ArkmicroFiles\libboard-amt630hv100; ..\ArkmicroFiles\libboard-amt630hv100\include; ..\ArkmicroFiles\libcpu-amt630hv100; ..\ArkmicroFiles\libcpu-amt630hv100\source\audio; ..\ArkmicroFiles\libcpu-amt630hv100\include; ..\lib\sfud\inc; ..\lib\gdi; ..\lib\LittlevGL; ..\lib\lib_rtos; ..\lib\littlefs; ..\lib\vg_driver; ..\lib\romfile; ..\lib\ulog; ..\lib\ulog\backend; ..\lib\EasyFlash\inc; ..\lib\HPatch; ..\FreeRTOS-Plus\FreeRTOS-Plus-CLI; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include\portable; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\private; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\FreeRTOS-Plus\FreeRTOS-FAT\include\; ..\FreeRTOS-Plus\FreeRTOS-FAT\portable\common; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\linux\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\asm\; ..\lib\awtk\awtk\3rd\xm\include; ..\lib\awtk\awtk\3rd\xm\include\vg; ..\lib\awtk\awtk\3rd\nanovg\base; ..\lib\awtk\awtk\src; ..\lib\awtk\awtk\src\ext_widgets; ..\lib\awtk\awtk\3rd\zlib; ..\lib\hx170dec\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\include\; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\NetworkInterface\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\NetworkInterface\rtl8821cs; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\Compiler\IAR\; ..\lib\bt\fsc_bt\; ..\app\carlink\common\; ..\app\vb7012_voice_assistant; ..\app\carlink\EY\; ..\app\carlink\EC\src\; ..\app\carlink\EC\include\; ..\app\carlink\CP\src\; ..\app\carlink\CP\include\; ..\app\carlink\AA\src\; ..\app\carlink\AA\include\; ..\lib\awtk\awtk\3rd\awtk-widget-qr\src; ..\lib\awtk\awtk\3rd\awtk-widget-qr\src\qr; ..\lib\lwip\src\include\; ..\lib\lwip\src\include\lwip\; ..\lib\lwip\src\include\arch\; ..\lib\lwip\src\include\compat\; ..\lib\lwip\src\include\netif\; ..\lib\wlan
  postbuild: as above
  ILINK.IlinkIcfFile: amt630hv100_awtk.icf
  ILINK.IlinkAdditionalLibs: ..\lib\vg_driver\VG_DRIVER_AWTK.a; ..\lib\awtk\awtk_rgb565.a; ..\lib\awtk\nanovg.a; ..\lib\wlan\aic8800\wlan_lib\aicwlan.a; ..\lib\wlan\aic8800\wlan_lib\aicwlan_if.a; ..\lib\bt\fsc_bt\lib\blueware.a; ..\app\carlink\EC\lib\ECTiny.a; ..\lib\faad2\libfaad.a; ..\lib\opus\opus.a; ..\lib\wolfssl\wolfssl.a; ..\app\carlink\CP\lib\carplay.a; ..\app\carlink\AA\lib\AndroidAuto.a
configuration AWTK_BW2232 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AMT630HV100; VG_DRIVER; AWTK; CARLINK_ENABLE; OSD_WIDTH=800; OSD_HEIGHT=480; HMI_AWTK; FREERTOS=1; USE_GUI_MAIN; LCD=VG_GPU; WITH_ASSET_LOADER; WITH_FS_RES; WITH_VGCANVAS; WITH_UNICODE_BREAK; HAS_PTHREAD=1; HAS_GET_TIME_US64; WITH_VG_GPU; WITH_FT_FONT; WITH_NANOVG_VG; XM_HMI_HOST; HAVE_CLOCK_GETTIME; USE_ROMFS_FS; APP_RES_ROOT="./"; __WITH_ARK_G2D; G_CHIP_RLT8733BS
  ICCARM.CCIncludePath2: as above
  postbuild: as above
  ILINK.IlinkIcfFile: amt630hv100_awtk.icf
  ILINK.IlinkAdditionalLibs: ..\lib\vg_driver\VG_DRIVER_AWTK.a; ..\lib\awtk\awtk_rgb565.a; ..\lib\awtk\nanovg.a; ..\lib\wlan\rtl8821cs\wlan_lib\wlan_lib_2232.a; ..\lib\wlan\rtl8821cs\wlan_lib\wlan_lib_2232_if.a; ..\lib\bt\fsc_bt\lib\blueware.a; ..\app\carlink\EC\lib\ECTiny.a; ..\lib\faad2\libfaad.a; ..\lib\opus\opus.a; ..\lib\wolfssl\wolfssl.a; ..\app\carlink\CP\lib\carplay.a; ..\app\carlink\AA\lib\AndroidAuto.a
configuration AWTK_BW8201 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AMT630HV100; VG_DRIVER; AWTK; CARLINK_ENABLE; USE_BW8201; G_CHIP_RLT8733BS; OSD_WIDTH=800; OSD_HEIGHT=480; HMI_AWTK; FREERTOS=1; USE_GUI_MAIN; LCD=VG_GPU; WITH_ASSET_LOADER; WITH_FS_RES; WITH_VGCANVAS; WITH_UNICODE_BREAK; HAS_PTHREAD=1; HAS_GET_TIME_US64; WITH_VG_GPU; WITH_FT_FONT; WITH_NANOVG_VG; XM_HMI_HOST; HAVE_CLOCK_GETTIME; USE_ROMFS_FS; APP_RES_ROOT="./"; __WITH_ARK_G2D
  ICCARM.CCIncludePath2: ..\.; ..\FreeRTOS\Source\include; ..\FreeRTOS\Source\portable; ..\demo\common\include; ..\ArkmicroFiles\libboard-amt630hv100; ..\ArkmicroFiles\libboard-amt630hv100\include; ..\ArkmicroFiles\libcpu-amt630hv100; ..\ArkmicroFiles\libcpu-amt630hv100\source\audio; ..\ArkmicroFiles\libcpu-amt630hv100\include; ..\lib\sfud\inc; ..\lib\gdi; ..\lib\LittlevGL; ..\lib\lib_rtos; ..\lib\littlefs; ..\lib\vg_driver; ..\lib\romfile; ..\lib\ulog; ..\lib\ulog\backend; ..\lib\EasyFlash\inc; ..\lib\HPatch; ..\FreeRTOS-Plus\FreeRTOS-Plus-CLI; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include\portable; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\private; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\FreeRTOS-Plus\FreeRTOS-FAT\include\; ..\FreeRTOS-Plus\FreeRTOS-FAT\portable\common; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\linux\; ..\ArkmicroFiles\libcpu-amt630hv100\source\usb\include\asm\; ..\lib\awtk\awtk\3rd\xm\include; ..\lib\awtk\awtk\3rd\xm\include\vg; ..\lib\awtk\awtk\3rd\nanovg\base; ..\lib\awtk\awtk\src; ..\lib\awtk\awtk\src\ext_widgets; ..\lib\awtk\awtk\3rd\zlib; ..\lib\hx170dec\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\include\; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\NetworkInterface\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\NetworkInterface\rtl8821cs; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\Compiler\IAR\; ..\lib\bt\fsc_bt_bw8201\; ..\lib\bt\fsc_bt_bw8201\example\; ..\app\carlink\common\; ..\app\vb7012_voice_assistant; ..\app\carlink\EY\; ..\app\carlink\EC\src\; ..\app\carlink\EC\include\; ..\app\carlink\CP\src\; ..\app\carlink\CP\include\; ..\app\carlink\AA\src\; ..\app\carlink\AA\include\; ..\lib\awtk\awtk\3rd\awtk-widget-qr\src; ..\lib\awtk\awtk\3rd\awtk-widget-qr\src\qr; ..\lib\lwip\src\include\; ..\lib\lwip\src\include\lwip\; ..\lib\lwip\src\include\arch\; ..\lib\lwip\src\include\compat\; ..\lib\lwip\src\include\netif\; ..\lib\wlan
  postbuild: as above
  ILINK.IlinkIcfFile: amt630hv100_awtk.icf
  ILINK.IlinkAdditionalLibs: ..\lib\vg_driver\VG_DRIVER_AWTK.a; ..\lib\awtk\awtk_rgb565.a; ..\lib\awtk\nanovg.a; ..\lib\wlan\rtl8821cs\wlan_lib\wlan_lib_8201.a; ..\lib\wlan\rtl8821cs\wlan_lib\wlan_lib_2232_if.a; ..\lib\bt\fsc_bt_bw8201\lib\blueware_bw8201.a; ..\app\carlink\EC\lib\ECTiny.a; ..\lib\faad2\libfaad.a; ..\lib\opus\opus.a; ..\lib\wolfssl\wolfssl.a; ..\app\carlink\CP\lib\carplay.a; ..\app\carlink\AA\lib\AndroidAuto.a
  group (top)
    ../: cstartup_with_FreeRTOS_vectors.s FreeRTOS_tick_config.c main.c os_adapt.c
  group app
    ../app/: ioapi.c main_awtk.c main_lvgl.c main_openvg.c md5.c myFont24.c myFont26.c net_log.c net_update.c unzip.c zip.c
  group app/awtk-examples/Chart.v2-Demo/src
    ../lib/awtk/awtk-examples/Chart.v2-Demo/src/: app_main.c window_bar_series.c window_line_series.c window_main.c window_meter.c window_pie.c window_series_common.c
  group app/awtk-examples/Chart.v2-Demo/src/custom_widgets
    ../lib/awtk/awtk-examples/Chart.v2-Demo/src/custom_widgets/: custom_widgets.c custom_widgets.h
  group app/awtk-examples/Chart.v2-Demo/src/custom_widgets/base
    ../lib/awtk/awtk-examples/Chart.v2-Demo/src/custom_widgets/base/: fifo.c fifo.h
  group app/awtk-examples/Chart.v2-Demo/src/custom_widgets/chart
    ../lib/awtk/awtk-examples/Chart.v2-Demo/src/custom_widgets/chart/: axis.c axis.h axis_p.c axis_p.h axis_types.h bar_series.c bar_series.h chart_animator.c chart_animator.h chart_utils.c chart_utils.h chart_view.c chart_view.h line_series.c line_series.h series.c series.h series_p.c series_p.h series_types.h tooltip.c tooltip.h tooltip_types.h vssver.scc x_axis.c x_axis.h y_axis.c y_axis.h
  group app/awtk-examples/Chart.v2-Demo/src/custom_widgets/pie_slice
    ../lib/awtk/awtk-examples/Chart.v2-Demo/src/custom_widgets/pie_slice/: pie_slice.c pie_slice.h
  group app/awtk-examples/CleanAir.v2-Demo/src
    ../lib/awtk/awtk-examples/CleanAir.v2-Demo/src/: app_main.c window_main.c window_record.c window_setting.c window_timing.c
  group app/awtk-examples/HelloDesigner-Demo/src
    ../lib/awtk/awtk-examples/HelloDesigner-Demo/src/: app_main.c window_animator_HelloDesigner_Demo.c window_background.c window_basic.c window_listview.c window_main.c
  group app/awtk-examples/HelloWorld.Xml-Demo/src
    ../lib/awtk/awtk-examples/HelloWorld.Xml-Demo/src/: app_main.c window_main.c
  group app/awtk-examples/Meter.v2-Demo/3rd/awtk-widget-qr/src
    ../lib/awtk/awtk-examples/Meter.v2-Demo/3rd/awtk-widget-qr/src/: qr_register.c qr_register.h
  group app/awtk-examples/Meter.v2-Demo/3rd/awtk-widget-qr/src/qr
    ../lib/awtk/awtk/3rd/awtk-widget-qr/src/qr/: bitstream.c bitstream.h config.h mask.c mask.h mmask.c mmask.h mqrspec.c mqrspec.h qr.c qr.h qrencode.c qrencode.h qrencode_inner.h qrinput.c qrinput.h qrspec.c qrspec.h rsecc.c rsecc.h split.c split.h
  group app/awtk-examples/Meter.v2-Demo/src
    ../lib/awtk/awtk-examples/Meter.v2-Demo/src/: app_main.c window_main.c
  group app/awtk-examples/MusicPlayer.v2-Demo/src
    ../lib/awtk/awtk-examples/MusicPlayer.v2-Demo/src/: app_main.c dialog_advanced.c dialog_equalizer.c window_main.c window_play_list.c
  group app/awtk-examples/MusicPlayer.v2-Demo/src/custom_function
    ../lib/awtk/awtk-examples/MusicPlayer.v2-Demo/src/custom_function/: knob_function.c knob_function.h music_manager.c music_manager.h player_timer_manager.c player_timer_manager.h
  group app/awtk-examples/MusicPlayer.v2-Demo/src/custom_widgets
    ../lib/awtk/awtk-examples/MusicPlayer.v2-Demo/src/custom_widgets/: custom_widgets.c custom_widgets.h
  group app/awtk-examples/MusicPlayer.v2-Demo/src/custom_widgets/base
    ../lib/awtk/awtk-examples/MusicPlayer.v2-Demo/src/custom_widgets/base/: fifo.c fifo.h
  group app/awtk-examples/MusicPlayer.v2-Demo/src/custom_widgets/chart
    ../lib/awtk/awtk-examples/MusicPlayer.v2-Demo/src/custom_widgets/chart/: axis.c axis.h axis_p.c axis_p.h axis_types.h bar_series.c bar_series.h chart_animator.c chart_animator.h chart_utils.c chart_utils.h chart_view.c chart_view.h line_series.c line_series.h series.c series.h series_p.c series_p.h series_types.h tooltip.c tooltip.h tooltip_types.h x_axis.c x_axis.h y_axis.c y_axis.h
  group app/awtk-examples/MusicPlayer.v2-Demo/src/custom_widgets/photo_frame
    ../lib/awtk/awtk-examples/MusicPlayer.v2-Demo/src/custom_widgets/photo_frame/: cover_view.c cover_view.h
  group app/awtk-examples/MusicPlayer.v2-Demo/src/custom_widgets/pie_slice
    ../lib/awtk/awtk-examples/MusicPlayer.v2-Demo/src/custom_widgets/pie_slice/: pie_slice.c pie_slice.h
  group app/awtk-examples/SmartWatch.v2-Demo/src
    ../lib/awtk/awtk-examples/SmartWatch.v2-Demo/src/: app_main.c window_main.c window_main.h
  group app/awtk-examples/SmartWatch.v2-Demo/src/application
    ../lib/awtk/awtk-examples/SmartWatch.v2-Demo/src/application/: calendar.c calendar.h health.c health.h heart_rate.c heart_rate.h heart_rate_check.c heart_rate_check.h music.c music.h weather.c weather.h
  group app/awtk-examples/SmartWatch.v2-Demo/src/common
    ../lib/awtk/awtk-examples/SmartWatch.v2-Demo/src/common/: animator.c animator.h global.c global.h log.h smartwatch_log.c
  group app/awtk-examples/SmartWatch.v2-Demo/src/custom_widgets
    ../lib/awtk/awtk-examples/SmartWatch.v2-Demo/src/custom_widgets/: bar_graph.c bar_graph.h custom_widgets.c custom_widgets.h gesture.c gesture.h guage_hour_pointer.c guage_hour_pointer.h guage_minute_pointer.c guage_minute_pointer.h guage_second_pointer.c guage_second_pointer.h health_circle.c health_circle.h hour_weather.c hour_weather.h slide_menu_v.c slide_menu_v.h
  group app/awtk-examples/SmartWatch.v2-Demo/src/slide_appliction
    ../lib/awtk/awtk-examples/SmartWatch.v2-Demo/src/slide_appliction/: app.c app.h message.c quick.c quick.h
  group app/awtk-examples/SmartWatch.v2-Demo/src/watch
    ../lib/awtk/awtk-examples/SmartWatch.v2-Demo/src/watch/: watch_01.c watch_01.h watch_02.c watch_02.h watch_04.c watch_04.h watch_06.c watch_06.h
  group app/carlink/aa
    ../app/carlink/AA/src/: carlink_aa.c
  group app/carlink/clcast
    ../app/carlink/clcast/src/: carlink_clcast.c carlink_clcast_ble.c clcast_ble_adapter.c clcast_ble_first_connection.c
  group app/carlink/common
    ../app/carlink/common/: ark_network.c carlink_bt_wifi.c carlink_clcast_ble_at.c carlink_common.c carlink_utils.c carlink_video.c
  group app/carlink/cp
    ../app/carlink/CP/src/: carlink_cp.c carlink_cp_audio_impl.c
  group app/carlink/ec
    ../app/carlink/EC/src/: carlink_ec.c
  group app/carlink/ey
    ../app/carlink/EY/: carlink_ey.c carlink_ey_qr.c carlink_ey_server.c carlink_ey_audio.c
  group app/double_pointer_halo
    ../app/double_pointer_halo/: double_arial.c double_pointer_demo.c double_vg_font.c
  group app/haoke
    ../app/haoke/: haoke_demo.c
  group app/haoke/images
    ../app/haoke/images/: haoke_demo_img_0.c haoke_demo_img_1.c haoke_demo_img_2.c haoke_demo_img_3.c haoke_demo_img_4.c haoke_demo_img_5.c haoke_demo_img_6.c haoke_demo_img_7.c haoke_demo_img_8.c haoke_demo_img_9.c haoke_demo_img_n0.c haoke_demo_img_n1.c haoke_demo_img_n10.c haoke_demo_img_n11.c haoke_demo_img_n12.c haoke_demo_img_n13.c haoke_demo_img_n14.c haoke_demo_img_n15.c haoke_demo_img_n16.c haoke_demo_img_n17.c haoke_demo_img_n18.c haoke_demo_img_n19.c haoke_demo_img_n2.c haoke_demo_img_n20.c haoke_demo_img_n21.c haoke_demo_img_n22.c haoke_demo_img_n23.c haoke_demo_img_n24.c haoke_demo_img_n25.c haoke_demo_img_n26.c haoke_demo_img_n27.c haoke_demo_img_n28.c haoke_demo_img_n29.c haoke_demo_img_n3.c haoke_demo_img_n30.c haoke_demo_img_n31.c haoke_demo_img_n32.c haoke_demo_img_n33.c haoke_demo_img_n34.c haoke_demo_img_n35.c haoke_demo_img_n36.c haoke_demo_img_n37.c haoke_demo_img_n38.c haoke_demo_img_n39.c haoke_demo_img_n4.c haoke_demo_img_n40.c haoke_demo_img_n41.c haoke_demo_img_n42.c haoke_demo_img_n43.c haoke_demo_img_n44.c haoke_demo_img_n45.c haoke_demo_img_n46.c haoke_demo_img_n47.c haoke_demo_img_n48.c haoke_demo_img_n49.c haoke_demo_img_n5.c haoke_demo_img_n50.c haoke_demo_img_n51.c haoke_demo_img_n52.c haoke_demo_img_n53.c haoke_demo_img_n54.c haoke_demo_img_n55.c haoke_demo_img_n56.c haoke_demo_img_n57.c haoke_demo_img_n58.c haoke_demo_img_n59.c haoke_demo_img_n6.c haoke_demo_img_n60.c haoke_demo_img_n61.c haoke_demo_img_n62.c haoke_demo_img_n63.c haoke_demo_img_n64.c haoke_demo_img_n65.c haoke_demo_img_n66.c haoke_demo_img_n67.c haoke_demo_img_n68.c haoke_demo_img_n69.c haoke_demo_img_n7.c haoke_demo_img_n70.c haoke_demo_img_n71.c haoke_demo_img_n72.c haoke_demo_img_n73.c haoke_demo_img_n74.c haoke_demo_img_n75.c haoke_demo_img_n76.c haoke_demo_img_n77.c haoke_demo_img_n78.c haoke_demo_img_n79.c haoke_demo_img_n8.c haoke_demo_img_n80.c haoke_demo_img_n9.c
  group app/pointer_halo
    ../app/pointer_halo/: arial_font.c pointer_halo.c vg_font.c
  group app/reverse_track
    ../app/reverse_track/: reversing_auxiliary_line.c
  group app/single_pointer_halo
    ../app/single_pointer_halo/: single_arial.c single_pointer_halo.c single_vg_font.c
  group app/vb7012_voice_assistant
    ../app/vb7012_voice_assistant/: vb7012_voice_assistant.c vb7012_voice_assistant.h vb7012_voice_assistant_awtk.c vb7012_voice_assistant_awtk.h vb7012_voice_assistant_demo.c vb7012_voice_assistant_demo.h
  group app/xinbas
    ../app/xinbas/: xinbas_demo.c
  group ArkmicroFiles/libboard-amt630hv100
    ../ArkmicroFiles/libboard-amt630hv100/source/: animation.c ark7116.c board_lowlevel.c carback.c crc32.c delta_update.c es7243e.c es8156.c keypad.c ota_update.c ringblk_buf.c rn6752.c romfile.c sysinfo.c touch.c updatefile.c
  group ArkmicroFiles/libboard-amt630hv100/touchscreen
    ../ArkmicroFiles/libboard-amt630hv100/source/touchscreen/: ft6336.c gt657x.c gt9xx.c touchscreen.c
  group ArkmicroFiles/libcpu-amt630hv100
    ../ArkmicroFiles/libcpu-amt630hv100/source/: adc.c aic.c blend2d.c can.c clock.c cpu_lcd.c dma.c dwspi.c ecspi.c gpio.c hx170dec.c i2c-dw.c i2c-gpio.c i2c.c i2s.c itu.c lcd.c mipi.c mmu.c pinctrl.c pwm.c pwm_cap.c pxp.c remote.c rtc.c sdmmc.c spi.c sysctl.c timer.c uart.c wdt.c
    ../ArkmicroFiles/libcpu-amt630hv100/cp15/: cp15.c cp15_asm_iar.s
  group ArkmicroFiles/libcpu-amt630hv100/audio
    ../ArkmicroFiles/libcpu-amt630hv100/source/audio/: audio.c drv_sound.c
  group ArkmicroFiles/libcpu-amt630hv100/sdio
    ../ArkmicroFiles/libcpu-amt630hv100/source/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
  group ArkmicroFiles/libcpu-amt630hv100/usb
    ../ArkmicroFiles/libcpu-amt630hv100/source/usb/: ark_dwc2.c core.c core_intr.c gadget.c hcd.c hcd_ddma.c hcd_intr.c hcd_queue.c params.c usb.c usb_massstorage.c usb_os_adapter.c usb_platform.c usb_uvc.c
  group ArkmicroFiles/libcpu-amt630hv100/usb/udc
    ../ArkmicroFiles/libcpu-amt630hv100/source/usb/udc/: composite.c config.c epautoconf.c ether.c f_ncm.c ncm.c udc-core.c usbstring.c
  group FreeRTOS
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/portable
    ../FreeRTOS/Source/portable/: port.c portASM.s
  group FreeRTOS/portable/MemMang
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
  group FreeRTOS-Plus/FreeRTOS-FAT
    ../FreeRTOS-Plus/FreeRTOS-FAT/: ff_crc.c ff_dir.c ff_error.c ff_fat.c ff_file.c ff_format.c ff_ioman.c ff_locking.c ff_memory.c ff_stdio.c ff_string.c ff_sys.c ff_time.c
  group FreeRTOS-Plus/FreeRTOS-FAT/portable
    ../FreeRTOS-Plus/FreeRTOS-FAT/portable/common/: ff_ramdisk.c
    ../FreeRTOS-Plus/FreeRTOS-FAT/portable/: ff_sddisk.c ff_sfdisk.c ff_usbdisk.c
  group FreeRTOS-Plus/FreeRTOS-Plus-CLI
    ../FreeRTOS-Plus/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c Sample-CLI-commands.c UARTCommandConsole.c
  group FreeRTOS-Plus/FreeRTOS-Plus-POSIX
    ../FreeRTOS-Plus/FreeRTOS-Plus-POSIX/FreeRTOS-Plus-POSIX/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group FreeRTOS-Plus/FreeRTOS-Plus-TCP
    ../FreeRTOS-Plus/FreeRTOS-Plus-TCP/: BufferAllocation.c FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DHCP_Server.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c iperf_task.c
  group FreeRTOS-Plus/FreeRTOS-Plus-TCP/portable/NetworkInterface
    ../FreeRTOS-Plus/FreeRTOS-Plus-TCP/portable/NetworkInterface/: NetworkInterface.c
  group lib/awtk/src/platforms/ark
    ../lib/awtk/awtk/src/platforms/ark/: ark_g2d.c fs_os.c platform.c thread_with_pthread.c
  group lib/bt/brt_bt
    ../lib/bt/brt_bt/: brt_bt.c
  group lib/bt/fsc_bt
    ../lib/bt/fsc_bt/: console.c fsc_bt.c
  group lib/bt/fsc_bt_bw8201
    ../lib/bt/fsc_bt_bw8201/example/: bt_ota_upgrade.c
    ../lib/bt/fsc_bt_bw8201/: fsc_bt_callback.c
  group lib/EasyFlash/ports
    ../lib/EasyFlash/ports/: ef_port.c
  group lib/EasyFlash/src
    ../lib/EasyFlash/src/: easyflash.c ef_log.c
  group lib/HPatch
    ../lib/HPatch/: file_for_patch.c patch.c
  group lib/hx170dec
    ../lib/hx170dec/src/: bqueue.c dwl_freertos.c dwl_freertos_sc.c h264_pp_pipeline.c h264decapi.c h264decapi_e.c h264hwd_asic.c h264hwd_byte_stream.c h264hwd_cabac.c h264hwd_cavlc.c h264hwd_conceal.c h264hwd_decoder.c h264hwd_dpb.c h264hwd_inter_prediction.c h264hwd_intra_prediction.c h264hwd_macroblock_layer.c h264hwd_nal_unit.c h264hwd_neighbour.c h264hwd_pic_order_cnt.c h264hwd_pic_param_set.c h264hwd_seq_param_set.c h264hwd_slice_data.c h264hwd_slice_group_map.c h264hwd_slice_header.c h264hwd_storage.c h264hwd_stream.c h264hwd_util.c h264hwd_vlc.c h264hwd_vui.c jpegdecapi.c jpegdechdrs.c jpegdecinternal.c jpegdecscan.c jpegdecutils.c mfcapi.c refbuffer.c regdrv.c tiledref.c workaround.c
  group lib/lib_rtos
    ../lib/lib_rtos/: lib_rtos.c
  group lib/littlefs
    ../lib/LittleFS/: lfs.c lfs_util.c
  group lib/LittlevGL/lv_examples/lv_demo_printer
    ../lib/LittlevGL/lv_examples/src/lv_demo_printer/: lv_demo_printer.c lv_demo_printer_theme.c
  group lib/LittlevGL/lv_examples/lv_demo_printer/images
    ../lib/LittlevGL/lv_examples/src/lv_demo_printer/images/: lv_demo_printer_icon_bright.c lv_demo_printer_icon_eco.c lv_demo_printer_icon_hue.c lv_demo_printer_icon_pc.c lv_demo_printer_icon_tel.c lv_demo_printer_icon_wifi.c lv_demo_printer_img_btn_bg_1.c lv_demo_printer_img_btn_bg_2.c lv_demo_printer_img_btn_bg_3.c lv_demo_printer_img_btn_bg_4.c lv_demo_printer_img_cloud.c lv_demo_printer_img_copy.c lv_demo_printer_img_internet.c lv_demo_printer_img_mobile.c lv_demo_printer_img_no_internet.c lv_demo_printer_img_phone.c lv_demo_printer_img_print.c lv_demo_printer_img_printer2.c lv_demo_printer_img_ready.c lv_demo_printer_img_scan.c lv_demo_printer_img_scan_example.c lv_demo_printer_img_setup.c lv_demo_printer_img_usb.c lv_demo_printer_img_wave.c
  group lib/LittlevGL/lvgl/src/lv_core
    ../lib/LittlevGL/lvgl/src/lv_core/: lv_refr.c
  group lib/lwip/src/api
    ../lib/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lib/lwip/src/apps
    ../lib/lwip/src/apps/lwiperf/: lwiperf.c
  group lib/lwip/src/arch
    ../lib/lwip/src/arch/: sys_arch.c
  group lib/lwip/src/core
    ../lib/lwip/src/core/: altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lib/lwip/src/core/ipv4
    ../lib/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lib/lwip/src/core/ipv6
    ../lib/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lib/lwip/src/netif
    ../lib/lwip/src/netif/: dhcp_server.c ethernet.c ethernetif.c
  group lib/sfud
    ../lib/sfud/src/: sfud.c sfud_sfdp.c snfud.c
    ../lib/sfud/port/: sfud_port.c
  group lib/ulog
    ../lib/ulog/: ulog.c
  group lib/ulog/backend
    ../lib/ulog/backend/: console_be.c ulog_easyflash_be.c ulog_file_be.c
  group lib/vg_driver
    ../lib/vg_driver/: vg_driver_wrapper.c
