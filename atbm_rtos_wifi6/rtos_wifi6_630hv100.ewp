# IAR project rtos_wifi6_630hv100.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: FREERTOS=1; __RTOS_FREERTOS__; ATBM_TCPIP_STACK=ATBM_TCPIP_STACK_FREERTOS_TCP
  ICCARM.CCIncludePath2: ..\.; ..\FreeRTOS\Source\include; ..\FreeRTOS\Source\portable; ..\demo\common\include; ..\ArkmicroFiles\libboard-amt630hv100; ..\ArkmicroFiles\libboard-amt630hv100\include; ..\ArkmicroFiles\libcpu-amt630hv100; ..\ArkmicroFiles\libcpu-amt630hv100\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-CLI; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include\portable; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\private; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\include\; ..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\Compiler\IAR\; ..\lib\lwip\src\include\; ..\lib\lwip\src\include\lwip\; ..\lib\lwip\src\include\arch\; ..\lib\lwip\src\include\compat\; ..\lib\lwip\src\include\netif\; ..\lib\wlan\atbm_wifi6\; ..\..\atbm_rtos_wifi6\include; ..\..\atbm_rtos_wifi6\os\include\; ..\..\atbm_rtos_wifi6\os\freertos\include; ..\..\atbm_rtos_wifi6\net\include\; ..\..\atbm_rtos_wifi6\net\include\proto; ..\..\atbm_rtos_wifi6\net\wpa\include\; ..\..\atbm_rtos_wifi6\net\wpa\crypto\include\; ..\..\atbm_rtos_wifi6\net\wpa\p2p\include\; ..\..\atbm_rtos_wifi6\net\wpa\sae\include\; ..\..\atbm_rtos_wifi6\net\wpa\wps\include\; ..\..\atbm_rtos_wifi6\hal\usb\; ..\..\atbm_rtos_wifi6\hal\sdio\; ..\..\atbm_rtos_wifi6\hal\compress\; ..\..\atbm_rtos_wifi6\hal\include\; ..\..\atbm_rtos_wifi6\api\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtos_wifi6.srec
  ILINK.IlinkOutputFile: rtos_wifi6.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; ATBM_TCPIP_STACK=ATBM_TCPIP_STACK_LWIP
  ICCARM.CCOptLevel: 3
  group api
    ../../atbm_rtos_wifi6/api/: atbm_api.c
  group hal
    ../../atbm_rtos_wifi6/hal/: atbm_ap.c atbm_bh.c atbm_config.c atbm_etf.c atbm_init.c atbm_main.c atbm_queue.c atbm_skbuf.c atbm_sta.c atbm_task.c atbm_thread.c atbm_timer.c atbm_txrx.c atbm_wifi_driver_api.c atbm_wsm.c smartconfig.c
  group hal/compress
    ../../atbm_rtos_wifi6/hal/compress/: compress.c pq.c
  group hal/sdio
    ../../atbm_rtos_wifi6/hal/sdio/: atbm_dcxo_dpll.c atbm_sdio.c atbm_sdio_fwio.c atbm_sdio_hwio.c
  group net
    ../../atbm_rtos_wifi6/net/: atbm_agg.c atbm_bridge.c atbm_connect.c atbm_key.c atbm_mgmt.c atbm_ratectrl.c atbm_rc80211_hmac.c atbm_util.c
  group net/wpa
    ../../atbm_rtos_wifi6/net/wpa/: aes_core.c hostapd_main.c sha1.c wpa_common.c wpa_debug.c wpa_event.c wpa_main.c wpabuf.c
  group net/wpa/crypto
    ../../atbm_rtos_wifi6/net/wpa/crypto/: aes-cbc.c base64.c bignum.c crypto_internal-modexp.c dh_group5.c dh_groups.c sha256-internal.c sha256.c
  group net/wpa/p2p
    ../../atbm_rtos_wifi6/net/wpa/p2p/: p2p.c p2p_build.c p2p_common.c p2p_dev_disc.c p2p_go_neg.c p2p_group.c p2p_invitation.c p2p_main.c p2p_parse.c p2p_pd.c p2p_sd.c p2p_utils.c wifi_display.c
  group net/wpa/sae
    ../../atbm_rtos_wifi6/net/wpa/sae/: crypto_mbedlts.c dragonfly.c ecp.c ecp_curves.c pmksa_cache.c sae.c
  group net/wpa/wps
    ../../atbm_rtos_wifi6/net/wpa/wps/: eap_common.c eap_register.c eap_server_wsc.c ieee802_11_common.c uuid.c wps_attr_build.c wps_attr_parse.c wps_attr_process.c wps_common.c wps_dev_attr.c wps_enrollee.c wps_hostapd.c wps_main.c wps_registrar.c wps_sta.c wps_validate.c
  group os
    ../../atbm_rtos_wifi6/os/freertos/: atbm_os_api.c atbm_os_atomic.c atbm_os_mem.c atbm_os_msgQ.c atbm_os_mutex.c atbm_os_sdio.c atbm_os_skbuf.c atbm_os_spinlock.c atbm_os_thread.c atbm_os_timer.c dhcps.c
  group os/test
    ../../atbm_rtos_wifi6/os/test/: atbm_os_test.c
